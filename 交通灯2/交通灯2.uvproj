# Keil uVision project 交通灯2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 交通灯2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Lcd1602.c
    ../: uart.c
    E:/实例源代码/lesson17/lesson17_1/: I2C.c
